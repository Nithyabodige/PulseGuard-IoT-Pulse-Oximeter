# Keil uVision project majorproject_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: majorproject_test +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s delay.c i2c.c i2c_eeprom.c interrupt_pg.c kpm.c lcd.c spi_eeprom.c main_pg.c MAX.c mcp3204.c menu_pg.c spi.c esp01.c uart0.c esp01_test.c esp01_test2.c timer0.c
